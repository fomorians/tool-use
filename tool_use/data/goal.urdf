Commit message: Update env block colors

File: tool_use/data/goal.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: mass 10 -> 1
